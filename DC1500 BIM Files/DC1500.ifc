Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-12-17T00:13:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 17 00:13:55 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\ae2c5c2c-2c28-4ea3-9ab6-7e9495856a3b\73b69708-45ec-4aea-8160-323347568905\ifc * Database version: 5507 * Database creation date: Tue Dec 17 00:13:55 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 17 00:13:55 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 17 00:13:55 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: DC1500, DC1500:DC1500:349911
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_97 : WC suites; CAWS: N13/10 WC pans and flushing arrangements_N13/300 WCs and cisterns; CodePerformance: EN997–CL2_DocM_LANTAC_BS8300; Color: White_Grey-Seat; Constituents: n/a; Description: WC Suite with close coupled cistern_Anti lateral seat retaining buffers-DC1510-GRY; DurationUnit: year; ExpectedLife: n/a; Features: 480ToSeat_DocMCompliant; Finish: Gloss; Form: FloorStanding_BackToWall; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: .CISTERN.TOILETPAN; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: Ceramic; ModelNumber: DC1500; ModelReference: DolphinSolutionsLimited_DocM_WCCloseCoupled; Name: DolphinSolutionsLimited_DocM_WCCloseCoupled_DC1500; NBSDescription: WC Suites; NBSReference: 45-35-70/380; NBSTypeID: n/a; NominalHeight: 870 mm; NominalLength: 750 mm; NominalWidth: 400 mm; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 870x750x400; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DC1500; Uniclass2015Code: Pr_40_20_93_97; Uniclass2015Title: WC suites; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DC1500
Type - Pset_SanitaryTerminalTypeBath - Color: White_Grey-Seat
Type - Pset_SanitaryTerminalTypeBidet - Color: White_Grey-Seat
Type - Pset_SanitaryTerminalTypeSanitaryFountain - Color: White_Grey-Seat
Type - Pset_SanitaryTerminalTypeShower - Color: White_Grey-Seat
Type - Pset_SanitaryTerminalTypeSink - Color: White_Grey-Seat
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: White_Grey-Seat
Pset_DistributionFlowElementCommon - Reference: DC1500:DC1500; sets with these values: 2
Pset_ElementShading - Color: White_Grey-Seat
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DocM_WCCloseCoupled; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: DolphinSolutionsLimited_DocM_WCCloseCoupled_DC1500; Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 1.16547 m2; Volume: 0.0703831 m3
Identity Data - Mark: 1
Other - Family: DC1500: DC1500; Family and Type: DC1500: DC1500; Type: DC1500: DC1500; Type Id: DC1500: DC1500
Phasing - Phase Created: New Construction
